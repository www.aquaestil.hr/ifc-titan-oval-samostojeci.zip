Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-07-20T13:07:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 20 13:07:45 2021 * Host: pr500ssd * Database: C:\Users\PREDRA~1.RAK\AppData\Local\Temp\{B9B60654-C191-43F5-9E95-131B695083D1}\ifc * Database version: 5507 * Database creation date: Tue Jul 20 13:07:43 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 20 13:07:44 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 20 13:07:44 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: 62x41x90, Titan Oval_umivaonik_samostojeci_R18:62x41x90:371011
In: Level 1
Material: AQ_Astone_white(1)
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil
Pset_DistributionFlowElementCommon - Reference: Titan Oval_umivaonik_samostojeci_R18:62x41x90
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 1.0263 m2; Volume: 0.0113542 m3
Identity Data - Mark: 13
Mechanical - System Classification: Sanitary
Other - Category: Plumbing Fixtures; Family: Titan Oval_umivaonik_samostojeci_R18: 62x41x90; Family and Type: Titan Oval_umivaonik_samostojeci_R18: 62x41x90; Type: Titan Oval_umivaonik_samostojeci_R18: 62x41x90; Type Id: Titan Oval_umivaonik_samostojeci_R18: 62x41x90
Phasing - Phase Created: New Construction
Identity Data(Type) - Boja: bijela; Izradio: Intelika d.o.o.; Manufacturer: Aquaestil; Materijal: Astone; Model: TITAN OVAL SAMOSTOJEĆI; Mogućnost ugradnje: samostojeći; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Sifon: Ø46; Type Name: 62x41x90; Web adresa: https://www.aquaestil.hr/hr/proizvodi/kupaonski-namjestaj/14-.html
Materials and Finishes(Type) - Materijal umivaonik: AQ_Astone_white(1)
Other(Type) - Category: Plumbing Fixtures; Family Name: Titan Oval_umivaonik_samostojeci_R18
